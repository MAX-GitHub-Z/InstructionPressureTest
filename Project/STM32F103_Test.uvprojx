# Keil uVision project STM32F103_Test.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_Test +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\APP\inc;..\STM32F10xFWLib\CMSIS;..\STM32F10xFWLib\CMSIS\startup;..\STM32F10xFWLib\STM32F10x_StdPeriph_Driver\inc;..\FreeRTOS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/src/: main.c
  group CMSIS
    ../STM32F10xFWLib/CMSIS/: system_stm32f10x.c core_cm3.c
    ../STM32F10xFWLib/CMSIS/startup/: startup_stm32f10x_hd.s
  group StdDriver
    ../STM32F10xFWLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../FreeRTOS/src/: heap_2.c list.c port.c queue.c tasks.c
